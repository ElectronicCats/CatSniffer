# IAR project sniffer_fw.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: CC1350F128 TexasInstruments CC1350F128
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: FW_ID=0
  ICCARM.IExtraOptions: -I$PROJ_DIR$; -f$COM_TI_SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/kernel/tirtos/builds/CC1350_LAUNCHXL/release/iar/compiler.opt.defs; -DDeviceFamily_CC13X0; -DCCFG_FORCE_VDDR_HH=0; -I$COM_TI_SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source; -I$COM_TI_SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source/ti/posix/iar; --debug; --silent; -e; --aeabi; --thumb; --diag_suppress=Pa050
  ICCARM.CCIncludePath2: ../../../source/smartrf_settings/cc13x0lp; ../../../source/phy; ../../../source/link_layer
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sniffer_fw.hex
  prebuild: iarbuild.exe $COM_TI_SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/kernel/tirtos/builds/CC1350_LAUNCHXL/release/iar/tirtos_builds_CC1350_LAUNCHXL_release.ewp Debug -log all
  ILINK.IlinkOutputFile: sniffer_fw.out
  ILINK.IlinkIcfFile: sniffer_fw_CC1350_LAUNCHXL_TIRTOS.icf
  ILINK.IlinkExtraOptions: -f$COM_TI_SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/kernel/tirtos/builds/CC1350_LAUNCHXL/release/iar/linker.cmd; $COM_TI_SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source/ti/display/lib/display.arm3; $COM_TI_SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source/ti/grlib/lib/iar/m3/grlib.a; $COM_TI_SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source/ti/drivers/rf/lib/rf_multiMode_cc13x0.arm3; $COM_TI_SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source/ti/drivers/lib/drivers_cc13x0.arm3; $COM_TI_SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/kernel/tirtos/packages/ti/dpl/lib/dpl_cc13x0.arm3; $COM_TI_SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source/ti/devices/cc13x0/driverlib/bin/iar/driverlib.lib; --silent; --cpu=Cortex-M3; --redirect; _Printf=_PrintfSmall; --redirect; _Scanf=_ScanfSmall
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 1
  group Sniffer_Fw/Documentation
    ./: Board.html README.html
  group Sniffer_Fw/Header files
    ./: Board.h CC1350_LAUNCHXL.h
    ../../../source/: command_handler.h command_packet.h common.h control_task.h data_packet.h data_task.h general_packet.h host_if.h host_if_task.h packet_handler.h packet_queue.h radio_if.h radio_if_dataqueue.h task_event.h test_command_handler.h timestamp.h user_if_task.h version.h
  group Sniffer_Fw/Header files/Link_Layer
    ../../../source/link_layer/: ll_common.h ll_default.h ll_manager.h ll_timer.h
  group Sniffer_Fw/Header files/Link_Layer/BLE
    ../../../source/link_layer/ble/: ll_ble.h
  group Sniffer_Fw/Header files/Link_Layer/WBMS
    ../../../source/link_layer/wbms/: ll_wbms.h ll_wbms_channel.h ll_wbms_frame.h
  group Sniffer_Fw/Header files/Phy
    ../../../source/phy/: phy_if_ble_5.h phy_if_ieee_15_4.h phy_if_prop.h phy_if_prop_15_4g.h phy_if_wbms.h phy_io_config.h phy_manager.h phy_rf_api.h phy_tables.h
  group Sniffer_Fw/SmartRF_Settings/IEEE_15_4g
    ../../../source/smartrf_settings/cc13x0lp/15.4g/: smartrf_settings_15_4g_0.c smartrf_settings_15_4g_0.h smartrf_settings_15_4g_1.c smartrf_settings_15_4g_1.h smartrf_settings_15_4g_2.c smartrf_settings_15_4g_2.h smartrf_settings_15_4g_3.c smartrf_settings_15_4g_3.h smartrf_settings_15_4g_4.c smartrf_settings_15_4g_4.h smartrf_settings_15_4g_5.c smartrf_settings_15_4g_5.h
  group Sniffer_Fw/SmartRF_Settings/RF_Proprietary
    ../../../source/smartrf_settings/cc13x0lp/rf_prop/: smartrf_settings_rf_prop_0.c smartrf_settings_rf_prop_0.h smartrf_settings_rf_prop_1.c smartrf_settings_rf_prop_1.h smartrf_settings_rf_prop_2.c smartrf_settings_rf_prop_2.h smartrf_settings_rf_prop_3.c smartrf_settings_rf_prop_3.h smartrf_settings_rf_prop_4.c smartrf_settings_rf_prop_4.h
  group Sniffer_Fw/Source files
    ./: CC1350_LAUNCHXL.c CC1350_LAUNCHXL_fxns.c sniffer_fw_CC1350_LAUNCHXL_TIRTOS.icf
    ../../../source/: command_handler.c common.c control_task.c data_task.c host_if.c host_if_task.c output_if.c packet_handler.c packet_queue.c packet_sniffer_fw.c radio_if.c radio_if_dataqueue.c task_event.c test_command_handler.c timestamp.c user_if_task.c
  group Sniffer_Fw/Source files/CC13x0
    ./: ccfg.c
  group Sniffer_Fw/Source files/Link_Layer
    ../../../source/link_layer/: ll_common.c ll_default.c ll_manager.c ll_timer.c
  group Sniffer_Fw/Source files/Link_Layer/BLE
    ../../../source/link_layer/ble/: ll_ble.c
  group Sniffer_Fw/Source files/Link_Layer/WBMS
    ../../../source/link_layer/wbms/: ll_wbms.c ll_wbms_channel.c ll_wbms_frame.c
  group Sniffer_Fw/Source files/Phy
    ../../../source/phy/: phy_if_ble_5.c phy_if_ieee_15_4.c phy_if_prop.c phy_if_prop_15_4g.c phy_if_wbms.c phy_manager.c
  group Sniffer_Fw/Source files/Phy/Devices
    ../../../source/phy/devices/cc13x0lp/: phy_io_config.c phy_tables.c
